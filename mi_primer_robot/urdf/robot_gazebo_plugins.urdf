Commit message: Simulación de robot funcionando

File: mi_primer_robot/urdf/robot_gazebo_plugins.urdf (robot description, URDF)
Before this commit: robot robot_pit, 7 links, 6 joints
Links:
- link rueda_caster_falso_link: geometry collision sphere radius=0.10
