Commit message: Se agregaron paquetes para gazebo

File: mi_primer_robot/urdf/robot.urdf (robot description, URDF)
Before this commit: robot robot_pit, 3 links, 2 joints
Joints:
- joint joint_chassis_rueda_derecha: origin xyz=0.0 0.275 0.0 rpy=0.0 0.0 0.0 -> xyz=0.0 0.275 0.0 rpy=-1.57 0.0 0.0
